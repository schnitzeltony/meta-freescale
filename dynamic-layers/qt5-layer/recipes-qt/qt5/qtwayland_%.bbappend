# etnaviv mesa does not have glx/dri
PACKAGECONFIG_remove_use-mainline-bsp = "xcomposite-glx"
